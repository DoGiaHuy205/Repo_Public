# Keil uVision project BTL.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BTL
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,RTE_DEVICE_STDPERIPH_FRAMEWORK,RTE_DEVICE_STDPERIPH_GPIO,RTE_DEVICE_STDPERIPH_RCC,RTE_DEVICE_STDPERIPH_ADC,RTE_DEVICE_STDPERIPH_DMA,RTE_DEVICE_STDPERIPH_TIM,RTE_DEVICE_STDPERIPH_I2C,RTE_DEVICE_STDPERIPH_USART,RTE_DEVICE_STDPERIPH_FLASH,RTE_DEVICE_STDPERIPH_SPI
  c include: ..\inc;..\inc\IP;..\inc\MID;..\inc\APP;..\lib\CMSIS\CM3\CoreSupport;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\STM32F10x_StdPeriph_Driver\inc;.\RTE\_Target_1;.\RTE\Device\STM32F103C8;..\fatfs
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ../inc/APP/: APP_main.h
    ../inc/IP/: IP_audio_capture.h IP_GPIO_BTN.h IP_oled_font.h IP_sd_spi.h IP_SYSCLK.h IP_USART1.h
    ../inc/MID/: MID_audio_filters.h MID_oled_ssd1306.h MID_sd_fatfs.h
  group src
    ../src/APP/: APP_main.c
    ../src/IP/: IP_audio_capture.c IP_GPIO_BTN.c IP_oled_font.c IP_sd_spi.c IP_SYSCLK.c IP_USART1.c
    ../src/MID/: MID_audio_filters.c MID_oled_ssd1306.c MID_sd_fatfs.c
  group fatfs
    ../fatfs/: ff.c diskio.c diskio.h ff.h ffconf.h
  group lib
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
